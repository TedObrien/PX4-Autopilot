## src/drivers/adc/ads7830/Kconfig
```kconfig
menuconfig DRIVERS_ADC_ADS7830
	bool "ads7830"
	default n
	---help---
		Enable support for ads7830
```
